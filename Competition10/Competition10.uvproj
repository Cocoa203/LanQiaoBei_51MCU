# Keil uVision project Competition10.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Competition10 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Key.c Key.h Delay.c Delay.h Nixie.c Nixie.h Timer.c Timer.h PCF8591.c PCF8591.h iic.h iic.c NE555N.c NE555N.h
